<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>airprobe_rtlsdr</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fc_slider</value></param>
<param><key>value</key><value>fc</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>925e6</value></param>
<param><key>step</key><value>2e5</value></param>
<param><key>stop</key><value>1990e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>g_slider</value></param>
<param><key>value</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ppm_slider</value></param>
<param><key>value</key><value>ppm</value></param>
<param><key>label</key><value>PPM Offset</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-150</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>150</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>-2*pi*shiftoff/samp_rate</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>4729</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>fc</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1876.60e6</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>fc_slider</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>gain</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>14</value></param>
</block>
<block>
<key>gsm_bcch_ccch_demapper</key>
<param><key>id</key><value>gsm_bcch_ccch_demapper_0</value></param>
<param><key>timeslot_nr</key><value>0</value></param>
<param><key>channel_types</key><value>[1,2,2,2,2,2,2,2,2,2]</value></param>
<param><key>starts_fn_mod51</key><value>[2,6,12,16,22,26,32,36,42,46]</value></param>
</block>
<block>
<key>gsm_bcch_ccch_sdcch4_demapper</key>
<param><key>id</key><value>gsm_bcch_ccch_sdcch4_demapper_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeslot_nr</key><value>0</value></param>
<param><key>channel_types</key><value>[1,2,2,2,7,7,7,7,135,135]</value></param>
<param><key>starts_fn_mod51</key><value>[2,6,12,16,22,26,32,36,42,46]</value></param>
</block>
<block>
<key>gsm_clock_offset_control</key>
<param><key>id</key><value>gsm_clock_offset_control_0</value></param>
<param><key>fc</key><value>fc</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_1</value></param>
</block>
<block>
<key>gsm_input</key>
<param><key>id</key><value>gsm_input_0</value></param>
<param><key>osr</key><value>4</value></param>
<param><key>ppm</key><value>0</value></param>
<param><key>samp_rate_in</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_message_printer</key>
<param><key>id</key><value>gsm_message_printer_1</value></param>
<param><key>prepend_string</key><value>""</value></param>
<param><key>print_gsmtap_header</key><value>False</value></param>
</block>
<block>
<key>gsm_receiver</key>
<param><key>id</key><value>gsm_receiver_0</value></param>
<param><key>osr</key><value>4</value></param>
</block>
<block>
<key>gsm_sdcch8_demapper</key>
<param><key>id</key><value>gsm_sdcch8_demapper_0</value></param>
<param><key>timeslot_nr</key><value>1</value></param>
<param><key>channel_types</key><value>[8,8,8,8,8,8,8,8,136,136,136,136]</value></param>
<param><key>starts_fn_mod51</key><value>[0,4,8,12,16,20,24,28,32,36,40,44]</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>fc_slider</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>250e3</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>ppm_slider</value></param>
<param><key>freq0</key><value>fc_slider-shiftoff</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>g_slider</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2000000.052982</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>shiftoff</value></param>
<param><key>label</key><value>shiftoff</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>400e3</value></param>
</block>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_bcch_ccch_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_bcch_ccch_sdcch4_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0_1</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>ppm</source_key><sink_key>ppm_in</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>gsm_message_printer_1</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_1</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_1</source_block_id><sink_block_id>gsm_message_printer_1</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_1</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_1</source_block_id><sink_block_id>gsm_message_printer_1</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_input_0</source_block_id><sink_block_id>gsm_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>C0</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_bcch_ccch_demapper_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_bcch_ccch_sdcch4_demapper_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_sdcch8_demapper_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_clock_offset_control_0</sink_block_id><source_key>measurements</source_key><sink_key>measurements</sink_key></connection>
<connection><source_block_id>gsm_sdcch8_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_1</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
